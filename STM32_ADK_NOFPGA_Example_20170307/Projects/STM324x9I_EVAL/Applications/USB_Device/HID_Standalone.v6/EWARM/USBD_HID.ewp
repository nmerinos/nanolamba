# IAR project USBD_HID.ewp, settings and files
configuration STM324x9I-EVAL_USBD-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_STM324x9I_EVAL; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc; ..\..\..\..\..\..\Drivers\BSP\STM324x9I_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_HID.hex
  ILINK.IlinkOutputFile: USBD_HID.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324x9I-EVAL_USBD-HS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  OBJCOPY.OOCOutputFile: USBD_HID.bin
configuration STM324x9I-EVAL_USBD-HS-IN-FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  OBJCOPY.OOCOutputFile: USBD_HID.bin
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: genMessage.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_apollo_interface.c usbd_conf.c usbd_desc.c utils.c utils.h
    ../Inc/: main.h
  group Application/User/Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
